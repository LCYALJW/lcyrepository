# Keil uVision project cs32f0xx_demo.uvprojx, settings and files
target cs32f0xx_start_demo (ARM-ADS)
  device: CS32F031K8U6 Chipsea
  pack: Chipsea.CS32F0xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: cs32f0xx_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: CS32F031
  c include: ..\Driver;..\User_Project
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./: cs32f0xx_int.c main.c ECR8660.c spi_adc.c command.c init.c common.c
  group Driver
    ../Driver/: adc.c systick.c usart.c tim.c w25x64.c i2c_ee.c
software components: CMSIS:CORE 3.40.0, Device:HAL:ADC 1.0.0, Device:HAL:CRC 1.0.0, Device:HAL:DEBUG 1.0.0, Device:HAL:DMA 1.0.0, Device:HAL:EXTI 1.0.0, Device:HAL:FWDT 1.0.0, Device:HAL:Flash 1.0.0, Device:HAL:Framework 1.0.0, Device:HAL:GPIO 1.0.0, Device:HAL:I2C 1.0.0, Device:HAL:PMU 1.0.0, Device:HAL:RCU 1.0.0, Device:HAL:RTC 1.0.0, Device:HAL:SPI 1.0.0, Device:HAL:SYSCFG 1.0.0, Device:HAL:TIM 1.0.0, Device:HAL:USART 1.0.0, Device:HAL:WWDT 1.0.0, Device:Startup 1.0.0
